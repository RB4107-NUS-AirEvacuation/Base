#include "drv_oled.h"
#include "drv_i2c.h"
#include <Wire.h>
#include <string.h>

// 5x7 font, ' ' (0x20) to 'Z' (0x5A). Each glyph is 5 columns, bit 0 = top pixel.
static const uint8_t FIRST_CHAR = 0x20;
static const uint8_t LAST_CHAR = 0x5A;
static const uint8_t kFont[][5] = {
  {0x00, 0x00, 0x00, 0x00, 0x00},  // ' '
  {0x00, 0x00, 0x5F, 0x00, 0x00},  // !
  {0x00, 0x07, 0x00, 0x07, 0x00},  // "
  {0x14, 0x7F, 0x14, 0x7F, 0x14},  // #
  {0x24, 0x2A, 0x7F, 0x2A, 0x12},  // $
  {0x23, 0x13, 0x08, 0x64, 0x62},  // %
  {0x36, 0x49, 0x55, 0x22, 0x50},  // &
  {0x00, 0x05, 0x03, 0x00, 0x00},  // '
  {0x00, 0x1C, 0x22, 0x41, 0x00},  // (
  {0x00, 0x41, 0x22, 0x1C, 0x00},  // )
  {0x14, 0x08, 0x3E, 0x08, 0x14},  // *
  {0x08, 0x08, 0x3E, 0x08, 0x08},  // +
  {0x00, 0x50, 0x30, 0x00, 0x00},  // ,
  {0x08, 0x08, 0x08, 0x08, 0x08},  // -
  {0x00, 0x60, 0x60, 0x00, 0x00},  // .
  {0x20, 0x10, 0x08, 0x04, 0x02},  // /
  {0x3E, 0x51, 0x49, 0x45, 0x3E},  // 0
  {0x00, 0x42, 0x7F, 0x40, 0x00},  // 1
  {0x42, 0x61, 0x51, 0x49, 0x46},  // 2
  {0x21, 0x41, 0x45, 0x4B, 0x31},  // 3
  {0x18, 0x14, 0x12, 0x7F, 0x10},  // 4
  {0x27, 0x45, 0x45, 0x45, 0x39},  // 5
  {0x3C, 0x4A, 0x49, 0x49, 0x30},  // 6
  {0x01, 0x71, 0x09, 0x05, 0x03},  // 7
  {0x36, 0x49, 0x49, 0x49, 0x36},  // 8
  {0x06, 0x49, 0x49, 0x29, 0x1E},  // 9
  {0x00, 0x36, 0x36, 0x00, 0x00},  // :
  {0x00, 0x56, 0x36, 0x00, 0x00},  // ;
  {0x08, 0x14, 0x22, 0x41, 0x00},  // <
  {0x14, 0x14, 0x14, 0x14, 0x14},  // =
  {0x00, 0x41, 0x22, 0x14, 0x08},  // >
  {0x02, 0x01, 0x51, 0x09, 0x06},  // ?
  {0x32, 0x49, 0x79, 0x41, 0x3E},  // @
  {0x7E, 0x11, 0x11, 0x11, 0x7E},  // A
  {0x7F, 0x49, 0x49, 0x49, 0x36},  // B
  {0x3E, 0x41, 0x41, 0x41, 0x22},  // C
  {0x7F, 0x41, 0x41, 0x22, 0x1C},  // D
  {0x7F, 0x49, 0x49, 0x49, 0x41},  // E
  {0x7F, 0x09, 0x09, 0x09, 0x01},  // F
  {0x3E, 0x41, 0x49, 0x49, 0x7A},  // G
  {0x7F, 0x08, 0x08, 0x08, 0x7F},  // H
  {0x00, 0x41, 0x7F, 0x41, 0x00},  // I
  {0x20, 0x40, 0x41, 0x3F, 0x01},  // J
  {0x7F, 0x08, 0x14, 0x22, 0x41},  // K
  {0x7F, 0x40, 0x40, 0x40, 0x40},  // L
  {0x7F, 0x02, 0x0C, 0x02, 0x7F},  // M
  {0x7F, 0x04, 0x08, 0x10, 0x7F},  // N
  {0x3E, 0x41, 0x41, 0x41, 0x3E},  // O
  {0x7F, 0x09, 0x09, 0x09, 0x06},  // P
  {0x3E, 0x41, 0x51, 0x21, 0x5E},  // Q
  {0x7F, 0x09, 0x19, 0x29, 0x46},  // R
  {0x46, 0x49, 0x49, 0x49, 0x31},  // S
  {0x01, 0x01, 0x7F, 0x01, 0x01},  // T
  {0x3F, 0x40, 0x40, 0x40, 0x3F},  // U
  {0x1F, 0x20, 0x40, 0x20, 0x1F},  // V
  {0x3F, 0x40, 0x38, 0x40, 0x3F},  // W
  {0x63, 0x14, 0x08, 0x14, 0x63},  // X
  {0x07, 0x08, 0x70, 0x08, 0x07},  // Y
  {0x61, 0x51, 0x49, 0x45, 0x43},  // Z
};

static const uint8_t CHAR_W = 6;          // 5 pixel glyph + 1 pixel gap
static const uint8_t CHUNK = 16;          // data bytes per I2C transfer (fits the Uno's 32-byte buffer too)

// I2C control byte: what the bytes after it are.
static const uint8_t CTRL_COMMANDS = 0x00;
static const uint8_t CTRL_DATA = 0x40;

DrvOled::DrvOled(uint8_t addr, int sda, int scl)
  : _addr(addr), _sda(sda), _scl(scl), _ok(false), _nextRow(ROWS) {
  clear();
}

bool DrvOled::sendCommands(const uint8_t* cmds, uint8_t n) {
  Wire.beginTransmission(_addr);
  Wire.write(CTRL_COMMANDS);
  Wire.write(cmds, n);
  return Wire.endTransmission() == 0;
}

bool DrvOled::begin() {
  drvI2cBegin(_sda, _scl);
  static const uint8_t init[] = {
    0xAE,         // display off
    0xD5, 0x80,   // clock divider: default
    0xA8, 0x1F,   // multiplex: 32 lines
    0xD3, 0x00,   // no vertical offset
    0x40,         // start at line 0
    0x8D, 0x14,   // charge pump on (panel powered from 3.3 V)
    0x20, 0x00,   // horizontal addressing: data fills a row left to right
    0xA1,         // mirror columns (so text is not backwards)
    0xC8,         // scan rows bottom-up (so text is not upside down)
    0xDA, 0x02,   // COM pin layout for 128 x 32 panels
    0x81, 0x8F,   // contrast
    0xD9, 0xF1,   // pre-charge period
    0xDB, 0x40,   // VCOMH level
    0xA4,         // show RAM contents
    0xA6,         // normal (not inverted)
    0x2E,         // scrolling off
    0xAF,         // display on
  };
  _ok = sendCommands(init, sizeof(init));
  if (!_ok) return false;

  clear();
  for (uint8_t r = 0; r < ROWS; r++) sendRow(r);   // blank the screen once, at startup
  _nextRow = ROWS;
  return true;
}

void DrvOled::clear() {
  memset(_buf, 0, sizeof(_buf));
}

void DrvOled::text(uint8_t row, uint8_t col, const char* s) {
  if (row >= ROWS) return;
  uint8_t* line = _buf + row * WIDTH;
  for (uint16_t x = col * CHAR_W; *s != '\0' && x + CHAR_W <= WIDTH; s++, x += CHAR_W) {
    char c = *s;
    if (c >= 'a' && c <= 'z') c = c - 'a' + 'A';
    if (c < FIRST_CHAR || c > LAST_CHAR) c = '?';
    memcpy(line + x, kFont[c - FIRST_CHAR], 5);
    line[x + 5] = 0x00;
  }
}

void DrvOled::invertRow(uint8_t row) {
  if (row >= ROWS) return;
  uint8_t* line = _buf + row * WIDTH;
  for (uint8_t x = 0; x < WIDTH; x++) line[x] ^= 0xFF;
}

void DrvOled::startFlush() {
  if (_ok) _nextRow = 0;
}

void DrvOled::flushStep() {
  if (!busy()) return;
  if (sendRow(_nextRow)) {
    _nextRow++;
  } else {
    _nextRow = ROWS;          // display not answering: drop this frame, try again next refresh
  }
}

bool DrvOled::sendRow(uint8_t row) {
  const uint8_t window[] = {
    0x21, 0, WIDTH - 1,       // columns 0..127
    0x22, row, row,           // this row only
  };
  if (!sendCommands(window, sizeof(window))) return false;

  const uint8_t* line = _buf + row * WIDTH;
  for (uint8_t x = 0; x < WIDTH; x += CHUNK) {
    Wire.beginTransmission(_addr);
    Wire.write(CTRL_DATA);
    Wire.write(line + x, CHUNK);
    if (Wire.endTransmission() != 0) return false;
  }
  return true;
}
